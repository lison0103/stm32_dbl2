# IAR project GEC-DBL2.ewp, settings and files
configuration GEC-DBL2-M (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; GEC_DBL2_MASTER; EWARMv5
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS; ..\Libraries\CMSIS\Include; ..\HARDWARE\LED; ..\HARDWARE\EWDT; ..\HARDWARE\CAN; ..\HARDWARE\SPI; ..\HARDWARE\TIMER; ..\HARDWARE\EXTI; ..\ESC\inc; ..\SAFETYTEST\SelfTestLib; ..\SAFETYTEST\; ..\BSP
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GEC-DBL2-M.hex
  ILINK.IlinkOutputFile: GEC-DBL2-M.out
  ILINK.IlinkIcfFile: GEC-DBL2-M_flash.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GEC-DBL2-S (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F302xB ST STM32F302xB
  General.CoreVariant: 39
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; EWARMv5; GEC_DBL2_SLAVE
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\Libraries\CMSIS; ..\Libraries\CMSIS\Include; ..\BSP; ..\HARDWARE\LED; ..\HARDWARE\EWDT; ..\HARDWARE\SPI; ..\HARDWARE\TIMER; ..\HARDWARE\CAN; ..\HARDWARE\ADC; ..\HARDWARE\MAX31865; ..\SAFETYTEST\SelfTestLib; ..\SAFETYTEST\; ..\ESC\inc
  OBJCOPY.OOCOutputFile: GEC-DBL2-S.hex
  ILINK.IlinkOutputFile: GEC-DBL2-S.out
  ILINK.IlinkIcfFile: GEC-DBL2-S_flash.icf
  group BSP
    ../BSP/: bsp_input.c bsp_iocfg.c crc16.c delay.c hw_test.c initial_devices.c safety_test.c sys.c
  group ESC
    ../ESC/inc/: esc.h
    ../ESC/src/: esc_comm_dualcpu.c esc_comm_safety.c esc_error_process.c
  group FWLib/CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c system_stm32f30x.c
  group FWLib/CMSIS/Starup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_cl.s startup_stm32f10x_md.s startup_stm32f30x.s
  group FWLib/STM32F10X_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FWLib/STM32F30X_StdPeriph_Driver
    ../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/EWDT/: ewdt.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MAX31865/: max31865.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timer.c
  group SafetyTest
    ../SAFETYTEST/: check_instruction.c check_instruction_post.s check_instruction_post_2.s config_test.c flag_test.c pc_test.c
  group SafetyTest/SelfTestLib
    ../SAFETYTEST/SelfTestLib/: stm32f10x_STLclockrun.c stm32f10x_STLclockstart.c stm32f10x_STLcpurunIARv5.s stm32f10x_STLcpustartIARv5.s stm32f10x_STLcrc16.c stm32f10x_STLcrc16Run.c stm32f10x_STLcrc32.c stm32f10x_STLcrc32Run.c stm32f10x_STLfullRamMc.c stm32f10x_STLmain.c stm32f10x_STLparam.h stm32f10x_STLstartup.c stm32f10x_STLtranspRamMc.c stm32f10x_STLtranspRamMx.c
  group USER
    ./: main.c stm32f10x_conf.h stm32f10x_it.c stm32f30x_conf.h stm32f30x_it.c
